# Keil uVision project Counting.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Counting +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: S:\FreeRTOSv9.0.0\FreeRTOS\Source\include;S:\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.
  asm include: S:\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: main.c Startup.s LCD.c lcd.h
    S:/FreeRTOSv9.0.0/FreeRTOS/Source/: tasks.c list.c queue.c
    S:/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    S:/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    S:/FreeRTOSv9.0.0/FreeRTOS/Source/include/: semphr.h
