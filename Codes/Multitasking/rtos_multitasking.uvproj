# Keil uVision project rtos_multitasking.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtos_multitasking +hex
  c flags: Optim=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: C:\Users\G50\Downloads\FreeRTOSv9.0.0\FreeRTOS\Source\include;C:\Users\G50\Downloads\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.
  asm include: C:\Users\G50\Downloads\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: rtos_multitasking.c
    C:/Users/G50/Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/Users/G50/Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    C:/Users/G50/Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    C:/Users/G50/Downloads/FreeRTOSv9.0.0/FreeRTOS/Demo/ARM7_LPC2129_Keil_RVDS/: Startup.s
    C:/Users/G50/Desktop/RTOS FireBird/RTOS/Yash_desai_module/FreeRTOS_Workshop-2014-10-07/FreeRTOS Workshop/FreeRTOS/Demo/yash_RTOS_Task_2/: LCD.c lcd.h
