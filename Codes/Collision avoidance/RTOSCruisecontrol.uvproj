# Keil uVision project RTOSCruisecontrol.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOSCruisecontrol +hex
  c flags: Optim=1
  c include: ..\..\..\Downloads\FreeRTOSv9.0.0\FreeRTOS\Source\include;..\..\..\Downloads\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.
  asm include: ..\..\..\Downloads\FreeRTOSv9.0.0\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ../../../Downloads/FreeRTOSv9.0.0/FreeRTOS/Demo/ARM7_LPC2129_Keil_RVDS/: Startup.s
    ../../../Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/include/: FreeRTOS.h FreeRTOSConfig.h
    ../../../Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/: tasks.c queue.c list.c
    ../../../Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    ../../../Downloads/FreeRTOSv9.0.0/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./: main.c
    ../../Fire Bird V LPC2148 2013-05-05/Expirements/14A_GUI_Control_Serial/: spi.c Lcd.c
    ../Collision_State/: uart.h
